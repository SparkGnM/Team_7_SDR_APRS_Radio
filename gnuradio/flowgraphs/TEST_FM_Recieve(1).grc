options:
  parameters:
    author: Miles Shamburger
    generate_options: qt_gui
    id: TEST_FM_Recieve
    output_language: python
    title: TEST_FM_Recieve
  states: {}

blocks:
- name: Alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.35'
  states: {}
- name: Freq
  id: variable_qtgui_range
  parameters:
    start: 144.1e6
    step: 20e3
    stop: 147.5e6
    value: 146.52e6
  states: {}
- name: RfGain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5'
    stop: '50'
    value: '45'
  states: {}
- name: Threshold
  id: variable_qtgui_range
  parameters:
    start: '-80'
    step: '1'
    stop: '60'
    value: '-60'
  states: {}
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: real
    value: 102.3e6
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.25'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: 5e3
    step: 5e3
    stop: 1e6
    value: 15e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 5e3
    quad_rate: int(samp_rate*6/25)
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(50e3)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(200e3)
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: Alpha
    threshold: '-50'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/spark/Downloads/Frustration.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/spark/snap/audacity/1208/Documents/KJ5KSJ_Testing.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    gain: '3'
    interp: '5'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: Freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: Freq
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Audio Source"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: '1024'
    name: '"Audio Source"'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After Filter Receive"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Direct Receive"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '48000'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '6'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '5'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fm_tx
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fm_tx
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0_1, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_2, '0']
- [blocks_add_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0_0, '0']
- [blocks_wavfile_source_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_1, '0', osmosdr_sink_0, '0']
- [low_pass_filter_0_1, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0_1, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', analog_nbfm_tx_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
